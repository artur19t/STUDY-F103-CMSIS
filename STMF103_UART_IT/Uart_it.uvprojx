# Keil uVision project Uart_it.uvprojx, settings and files
target STM32F103 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Uart_it
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\hw_init\Inc;.\hw_init\Src
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App
    ./: main.c
  group hw_init
    ./hw_init/Src/: hw_gpio.c hw_usart.c
    ./hw_init/Inc/: hw_gpio.h hw_usart.h
software components: CMSIS:CORE 6.1.1, Device:Startup 1.0.0
